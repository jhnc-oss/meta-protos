GITHUB_MIRROR = "https://github.com"
GITLAB_MIRROR = "https://gitlab.com"
