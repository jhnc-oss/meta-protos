SUMMARY = "PROTOS devtools package group"

inherit packagegroup

RDEPENDS:${PN} = "\
    extra-cmake-modules \
"

