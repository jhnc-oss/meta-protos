require glibc-scripts.inc
require glibc-version.inc
