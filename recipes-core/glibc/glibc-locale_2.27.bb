require glibc-locale.inc
require glibc-version.inc
