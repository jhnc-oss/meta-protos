SUMMARY = "Protos test libraries"

inherit packagegroup

RDEPEND_${PN} = "\
    catch3 \
"
